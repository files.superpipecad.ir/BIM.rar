Properties of the parts of a building model (IFC4)

# File
Time: 2023-11-21T11:00:03
Written by: Xbim.IO.MemoryModel Processor version 5.1.0.0
Made in: SuperpipeCAD 5 IR 25.5 © InstalSoft

# IfcBuilding, ساختمان:
Pset_BuildingCommon - NetPlannedArea: 0 m2; NumberOfStoreys: 4

# IfcBuildingStorey (4)
In: ساختمان:
Name (طبقه:...) | Elevation (m)
B1 | -2.6
G0 | 0.9
F1 | 5.34
F2 | 9.78

# IfcPipeSegment: لوله سوپرپایپ +2 (24)
Type - Description: 0; ApplicableOccurrence: ‎16‎ * ‎2/0‎; ElementType: 651810101; PredefinedType: لوله سوپرپایپ +2
Description: نوع لوله:لوله سوپرپایپ +2
Pset_PipeSegmentTypeCommon - CatalogueCode: ‎700160‎-‎I‎; OuterDiameter: 16 mm; InnerDiameter: 12 mm; PurposeOfTheMedium: آب آشامیدنی
Name (خط لوله:...) | In | Reference | Pipe-runType | Location | VolumetricFlowRate (dm³/s) | PressureDropAcrossFittings (Pa) | FlowVelocity (m/s) | SpecificFrictionResistance (kg/m2/s2) | TotalFrictionResistanceAndPressureDropAcrossFittings (Pa) = TotalPressureDropAlongPipe-run (Pa) | InletTemperature (C) | DecreaseOfTemperatureOfMediumInPipe-run (K) | SumOfNormativeOutflows (dm³/s) | Length (m)
آب داغ | طبقه:G0 | 4 | آب داغ | واحد آپارتمانی | 0.0786525 | 2336.66 | 0.695441 | 537.504 | 3042.26 | 54.3144 | 0.0824545 | 0.14 | 1.31273
آب سرد | طبقه:G0 | 7 | آب سرد | خط اتصال/لوله اتصال TU | 0.13 | 5415.98 | 1.14945 | 1709.82 | 11147.6 | 5.2194 | -0.0470289 | 0.13 | 3.35215
آب سرد | طبقه:G0 | 4 | آب سرد | واحد آپارتمانی | 0.21404 | 5371.4 | 1.89253 | 4104.04 | 12087.1 | 5.20289 | -0.013961 | 0.27 | 1.63636
آب سرد | طبقه:G0 | 6 | آب سرد | واحد آپارتمانی | 0.150078 | 2024.59 | 1.32698 | 2199.78 | 2485.56 | 5.21685 | -0.00255093 | 0.2 | 0.209553
آب سرد | طبقه:G0 | 3 | آب سرد | خط اتصال/لوله اتصال TU | 0.07 | 957.508 | 0.618936 | 579.319 | 2848.44 | 5.20289 | -0.0849214 | 0.07 | 3.26407
آب داغ | طبقه:G0 | 2_A | آب داغ | واحد آپارتمانی | 0.16023 | 7025.44 | 1.41674 | 1886.94 | 9305.74 | 54.366 | 0.0372877 | 0.21 | 1.20846
آب داغ | طبقه:G0 | 4_A | آب داغ | واحد آپارتمانی | 0.0786525 | 0 | 0.695441 | 537.599 | 17.4835 | 54.2319 | 0.00204544 | 0.14 | 0.0325214
آب سرد | طبقه:G0 | 8_A | آب سرد | خط اتصال/لوله اتصال TU | 0.07 | 536.203 | 0.618936 | 578.643 | 6360.98 | 5.25975 | -0.260139 | 0.07 | 10.0663
آب سرد | طبقه:G0 | 8 | آب سرد | خط اتصال/لوله اتصال TU | 0.07 | 1800.11 | 0.618936 | 579.346 | 2697.17 | 5.2194 | -0.040353 | 0.07 | 1.54839
آب داغ | طبقه:G0 | 6_A | آب داغ | خط اتصال/لوله اتصال TU | 0.07 | 528.952 | 0.618936 | 438.882 | 5012.69 | 54.0883 | 0.713486 | 0.07 | 10.2163
آب داغ | طبقه:G0 | 2_B | آب داغ | واحد آپارتمانی | 0.16023 | 395.804 | 1.41674 | 1887.14 | 1272.57 | 54.3287 | 0.0143409 | 0.21 | 0.464598
آب سرد | طبقه:G0 | 5 | آب سرد | خط اتصال/لوله اتصال TU | 0.07 | 1570.31 | 0.618936 | 579.221 | 3772.6 | 5.21685 | -0.0988681 | 0.07 | 3.80215
آب داغ | طبقه:G0 | 3 | آب داغ | خط اتصال/لوله اتصال TU | 0.07 | 1548.71 | 0.618936 | 438.016 | 3022.23 | 54.3144 | 0.236815 | 0.07 | 3.36407
آب داغ | طبقه:G0 | 6 | آب داغ | خط اتصال/لوله اتصال TU | 0.07 | 1775.39 | 0.618936 | 438.085 | 2655.04 | 54.2299 | 0.141573 | 0.07 | 2.00794
آب داغ | طبقه:G0 | 5 | آب داغ | خط اتصال/لوله اتصال TU | 0.07 | 1548.79 | 0.618936 | 438.208 | 3258.75 | 54.2299 | 0.274522 | 0.07 | 3.90215
آب داغ | طبقه:G0 | 2 | آب داغ | واحد آپارتمانی | 0.16023 | 11576.2 | 1.41674 | 1885.66 | 30054.3 | 54.6671 | 0.301046 | 0.21 | 9.79931
آب سرد | طبقه:F1 | 11_A | آب سرد | خط اتصال/لوله اتصال TU | 0.15 | 1406.95 | 1.32629 | 2196.57 | 27715.4 | 5.21629 | -0.145082 | 0.15 | 11.977
آب داغ | طبقه:F1 | 7_B | آب داغ | واحد آپارتمانی | 0.169998 | 8352.69 | 1.50311 | 2093.54 | 11314.8 | 54.5964 | 0.0411461 | 0.22 | 1.41489
آب داغ | طبقه:F1 | 8_A | آب داغ | خط اتصال/لوله اتصال TU | 0.15 | 1387.59 | 1.32629 | 1679.85 | 23151.3 | 54.4271 | 0.424289 | 0.15 | 12.9558
آب سرد | طبقه:F1 | 11 | آب سرد | خط اتصال/لوله اتصال TU | 0.15 | 7298.56 | 1.32629 | 2198.01 | 11409.1 | 5.19353 | -0.0227598 | 0.15 | 1.87014
آب داغ | طبقه:F1 | 7_C | آب داغ | واحد آپارتمانی | 0.169998 | 890.976 | 1.50311 | 2093.96 | 5220.42 | 54.5553 | 0.0601081 | 0.22 | 2.06758
آب داغ | طبقه:F1 | 7_A | آب داغ | واحد آپارتمانی | 0.169998 | 7907.04 | 1.50311 | 2093.17 | 11232.3 | 54.6426 | 0.0461946 | 0.22 | 1.58863
آب داغ | طبقه:F1 | 8 | آب داغ | خط اتصال/لوله اتصال TU | 0.15 | 6850.37 | 1.32629 | 1678.17 | 10320.1 | 54.4952 | 0.0681125 | 0.15 | 2.06758
آب داغ | طبقه:G0 | 7 | آب داغ | رایزر | 0.169998 | 10356.9 | 1.50311 | 2092.87 | 12114.9 | 54.6671 | 0.0244346 | 0.22 | 0.84

# IfcPipeSegment: لوله سوپرپایپ +2 (12)
Type - Description: 0; ApplicableOccurrence: ‎20‎ * ‎2/25‎; ElementType: 651810102; PredefinedType: لوله سوپرپایپ +2
Description: نوع لوله:لوله سوپرپایپ +2
Pset_PipeSegmentTypeCommon - CatalogueCode: ‎700200‎-‎I‎; OuterDiameter: 20 mm; InnerDiameter: 15.5 mm; PurposeOfTheMedium: آب آشامیدنی
Name (خط لوله:...) | In | Reference | Pipe-runType | Location | VolumetricFlowRate (dm³/s) | PressureDropAcrossFittings (Pa) | FlowVelocity (m/s) | SpecificFrictionResistance (kg/m2/s2) | TotalFrictionResistanceAndPressureDropAcrossFittings (Pa) = TotalPressureDropAlongPipe-run (Pa) | InletTemperature (C) | DecreaseOfTemperatureOfMediumInPipe-run (K) | SumOfNormativeOutflows (dm³/s) | Length (m)
آب داغ | طبقه:B1 | 1 | آب داغ | شبکه | 0.320726 | 8970.51 | 1.69973 | 1900.82 | 30206.1 | 55 | 0.205721 | 0.43 | 11.1718
آب سرد | طبقه:G0 | 2_B | آب سرد | واحد آپارتمانی | 0.26571 | 396.506 | 1.40817 | 1776.14 | 1665.73 | 5.19698 | -0.00590336 | 0.34 | 0.714598
آب سرد | طبقه:G0 | 2_A | آب سرد | واحد آپارتمانی | 0.26571 | 5055.45 | 1.40817 | 1776.25 | 7201.98 | 5.187 | -0.00998167 | 0.34 | 1.20846
آب سرد | طبقه:G0 | 2 | آب سرد | واحد آپارتمانی | 0.26571 | 8227.5 | 1.40817 | 1776.88 | 25817.3 | 5.10546 | -0.0815444 | 0.34 | 9.89931
آب سرد | طبقه:F1 | 10 | آب سرد | واحد آپارتمانی | 0.237375 | 4667.63 | 1.258 | 1457.29 | 7534.98 | 5.14901 | -0.0181861 | 0.3 | 1.96758
آب سرد | طبقه:F1 | 9_B | آب سرد | واحد آپارتمانی | 0.285237 | 6282.74 | 1.51165 | 2013.17 | 8627.87 | 5.12491 | -0.00896341 | 0.37 | 1.16489
آب سرد | طبقه:F1 | 9_C | آب سرد | واحد آپارتمانی | 0.285237 | 913.853 | 1.51165 | 2012.99 | 4874.57 | 5.13388 | -0.0151363 | 0.37 | 1.96758
آب سرد | طبقه:F1 | 9_A | آب سرد | واحد آپارتمانی | 0.285237 | 5825.82 | 1.51165 | 2013.34 | 9225.6 | 5.11192 | -0.0129914 | 0.37 | 1.68863
آب سرد | طبقه:F1 | 10_B | آب سرد | واحد آپارتمانی | 0.237375 | 632.899 | 1.258 | 1456.99 | 3328.53 | 5.17643 | -0.0171013 | 0.3 | 1.85014
آب سرد | طبقه:F1 | 10_A | آب سرد | واحد آپارتمانی | 0.237375 | 4034.73 | 1.258 | 1457.14 | 5490.02 | 5.1672 | -0.00923425 | 0.3 | 0.998726
آب داغ | طبقه:G0 | 1_A | آب داغ | رایزر | 0.320726 | 0 | 1.69973 | 1902.06 | 13124.2 | 54.7943 | 0.127224 | 0.43 | 6.9
آب سرد | طبقه:G0 | 9 | آب سرد | رایزر | 0.285237 | 7082.37 | 1.51165 | 2013.49 | 8773.7 | 5.10546 | -0.00646412 | 0.37 | 0.84

# IfcPipeSegment: لوله سوپرپایپ +2 (2)
Type - Description: 0; ApplicableOccurrence: ‎25‎ * ‎2/5‎; ElementType: 651810103; PredefinedType: لوله سوپرپایپ +2
Description: نوع لوله:لوله سوپرپایپ +2
Pset_PipeSegmentTypeCommon - CatalogueCode: ‎700250‎-‎I‎; OuterDiameter: 25 mm; InnerDiameter: 20 mm; Pipe-runType: آب سرد; VolumetricFlowRate: 0.446758 dm³/s; FlowVelocity: 1.42208 m/s; SumOfNormativeOutflows: 0.71 dm³/s; PurposeOfTheMedium: آب آشامیدنی
Name (خط لوله:...) | In | Reference | Location | PressureDropAcrossFittings (Pa) | SpecificFrictionResistance (kg/m2/s2) | TotalFrictionResistanceAndPressureDropAcrossFittings (Pa) = TotalPressureDropAlongPipe-run (Pa) | InletTemperature (C) | DecreaseOfTemperatureOfMediumInPipe-run (K) | Length (m)
آب سرد | طبقه:B1 | 1 | شبکه | 5459.12 | 1319.17 | 19932.8 | 5 | -0.0647191 | 10.9718
آب سرد | طبقه:G0 | 1_A | رایزر | 0 | 1318.65 | 9098.66 | 5.06472 | -0.040738 | 6.9

# IfcSanitaryTerminal (8)
Name | In | Description
منبع: | طبقه:B1
شير تامین آب:_سینکA | طبقه:G0 | نوع:شیر مخلوط سینک; نوع نقطه خروجي آب:شیر مخلوط سینک
فلاش تانک:_WCF | طبقه:G0 | نوع:فلاش تانک - ورودی از وسط; نوع نقطه خروجي آب:شیر پرکن مخزن
شير تامین آب:_WbI | طبقه:G0 | نوع:شیر مخلوط روشویی; نوع نقطه خروجي آب:شیر مخلوط روشویی
شير تامین آب:_WbB | طبقه:G0 | نوع:شیر مخلوط روشویی; نوع نقطه خروجي آب:شیر مخلوط روشویی
نقطه توزیع آب:_WME | طبقه:F1 | نوع:ماشین لباسشویی Vr=0.15; نوع نقطه خروجي آب:ماشین لباسشویی
شير تامین آب:_سینکD | طبقه:F1 | نوع:شیر مخلوط سینک; نوع نقطه خروجي آب:شیر مخلوط سینک
شير تامین آب:_زیردوشیC | طبقه:F1 | نوع:شیر مخلوط برای دوش; نوع نقطه خروجي آب:شیر مخلوط دوش

# IfcPipeSegmentType, no part of this type: لوله سوپرپایپ +2
Description: 0; ApplicableOccurrence: لوله سوپرپایپ +2; PredefinedType: 651810100

# IfcPipeSegmentType, no part of this type: لوله سوپرپایپ +2
Description: 0; ApplicableOccurrence: ‎32‎ * ‎3/0‎; ElementType: 651810104; PredefinedType: لوله سوپرپایپ +2
